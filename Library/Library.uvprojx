# Keil uVision project Library.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Library (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Level_crossing
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ../PWM_module/: PWM_module.c
    ../Switch_1_module/: Switch_1_module.c
    ../UART_receiver_module/: UART_receiver_module.c
    ../UART_sender_module/: UART_sender_module.c
    ../UART_sender_module_3/: UART_sender_module_3.c
    ../UART_receiver_module_3/: UART_receiver_module_3.c
    ../LEDs_module/: LEDs_module.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
